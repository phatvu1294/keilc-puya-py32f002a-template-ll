# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: PY32F002Ax5 Puya
  pack: Puya.PY32F0xx_DFP.1.1.3
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER, USE_FULL_ASSERT, PY32F002Ax5
  c include: ..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PY32F0xx\Source;..\Drivers\CMSIS\Device\PY32F0xx\Source\arm;..\Drivers\CMSIS\Device\PY32F0xx\Include;..\Drivers\PY32F0xx_HAL_Driver\Src;..\Drivers\PY32F0xx_HAL_Driver\Inc;..\Drivers\PY32F0xx_HAL_Driver;..\Libraries;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Startup
    ../Drivers/CMSIS/Device/PY32F0xx/Source/arm/: startup_py32f002ax5.s
  group CMSIS
    ../Drivers/CMSIS/Device/PY32F0xx/Source/: system_py32f0xx.c
  group User
    ./User/: main.c py32f0xx_it.c
  group PY32F0xx_HAL_Driver
    ../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_ll_adc.c py32f0xx_ll_comp.c py32f0xx_ll_crc.c py32f0xx_ll_dma.c py32f0xx_ll_exti.c py32f0xx_ll_gpio.c py32f0xx_ll_i2c.c py32f0xx_ll_led.c py32f0xx_ll_lptim.c py32f0xx_ll_pwr.c py32f0xx_ll_rcc.c py32f0xx_ll_rtc.c py32f0xx_ll_spi.c py32f0xx_ll_tim.c py32f0xx_ll_usart.c py32f0xx_ll_utils.c
  group Libraries
    ../Libraries/: pv_startup.c pv_delay.c
